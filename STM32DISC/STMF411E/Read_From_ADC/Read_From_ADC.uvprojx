# Keil uVision project Read_From_ADC.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Read_From_ADC
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ./: main.c
  group Drivers_Sources
    ./: Drivers.c
  group Driver_Includes
    ./: Drivers.h
software components: CMSIS:CORE 5.0.2, Device:STM32Cube Framework:Classic 1.6.0, Device:STM32Cube HAL:ADC 1.6.0, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:Startup 2.6.0
