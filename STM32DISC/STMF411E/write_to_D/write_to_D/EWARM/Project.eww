<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\write_to_D.ewp</path>
  </project>
  <batchBuild />
</workspace>
