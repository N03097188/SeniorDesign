<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\HSE_Clock_Measure.ewp</path>
  </project>
  <batchBuild />
</workspace>
